options:
  parameters:
    generate_options: qt_gui
    id: all_test_blocks
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: stop_time_s
  id: variable
  parameters:
    value: '5'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: nouradio_test_define_test_0
  id: nouradio_test_define_test
  parameters:
    name: Enabled Test
  states: {}
- name: nouradio_test_define_test_0_0
  id: nouradio_test_define_test
  parameters:
    comment: Disabled Test
    name: Disabled Test
  states: {state: disabled}
- name: nouradio_test_run_command_0
  id: nouradio_test_run_command
  parameters:
    args: ''
    command: '"dir"'
    command_type: command
    execute_at: start
    script_path: ''
    test_name_filter: .*
    type: complex
  states: {}
- name: nouradio_test_run_tests_wrapper_0
  id: nouradio_test_run_tests_wrapper
  parameters:
    artifacts_dir: test_artifacts
    delay_before_close_s: '1'
    staging_dir: ''
    stop_after_sample: int(samp_rate * stop_time_s)
    suppress_runner: 'False'
    test_name_filter: .*
    type: complex
  states: {}
- name: nouradio_test_screenshot_0
  id: nouradio_test_screenshot
  parameters:
    auto_crop: 'True'
    auto_maximize: 'False'
    crop: '[0,0,1,1]'
    delay_samples: samp_rate
    monitor: '1'
    period_samples: 'samp_rate '
    test_name_filter: .*
    type: complex
  states: {}
- name: nouradio_test_stream_watch_0
  id: nouradio_test_stream_watch
  parameters:
    lower_bound: '-0.9'
    mode: above
    save_to: stream_out_of_bounds
    test_name_filter: .*
    type: float
    upper_bound: '1.0'
  states: {}
- name: nouradio_test_variable_change_0
  id: nouradio_test_variable_change
  parameters:
    choices: ''
    count: '100'
    mode: range
    start_value: '1'
    step: '1'
    stop_value: '5'
    test_name_filter: .*
    value: '0'
    variable: stop_time_s
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_complex_to_real_0, '0']
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [analog_sig_source_x_0, '0', nouradio_test_run_command_0, '0']
- [analog_sig_source_x_0, '0', nouradio_test_run_tests_wrapper_0, '0']
- [analog_sig_source_x_0, '0', nouradio_test_screenshot_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_real_0, '0', nouradio_test_stream_watch_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
